IMAGE_INSTALL:append = " waydroid-setup"